.SUBCKT irf7807zpbf 1 2 3
* SPICE3 MODEL WITH THERMAL RC NETWORK
**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* Model generated on Jan 13, 16
* MODEL FORMAT: SPICE3
* Symmetry POWER MOS Model (Version 1.0)
* External Node Designations
* Node 1 -> Drain
* Node 2 -> Gate
* Node 3 -> Source
M1 9 7 8 8 MM L=100u W=100u
.MODEL MM NMOS LEVEL=1 IS=1e-32
+VTO=2.3232 LAMBDA=0.0286451 KP=39.8082
+CGSO=7.20074e-06 CGDO=3.56318e-07
RS 8 3 0.00509693
D1 3 1 MD
.MODEL MD D IS=4.29463e-11 RS=0.00549294 N=1.14712 BV=30
+IBV=0.00025 EG=1.2 XTI=1 TT=1e-07
+CJO=3.00215e-10 VJ=1.04749 M=0.460734 FC=0.5
RDS 3 1 5e+07
RD 9 1 0.0001
RG 2 7 2.98365
D2 4 5 MD1
* Default values used in MD1:
*   RS=0 EG=1.11 XTI=3.0 TT=0
*   BV=infinite IBV=1mA
.MODEL MD1 D IS=1e-32 N=50
+CJO=1.25488e-10 VJ=1.88339 M=0.3 FC=1e-08
D3 0 5 MD2
* Default values used in MD2:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   BV=infinite IBV=1mA
.MODEL MD2 D IS=1e-10 N=0.4 RS=3e-06
RL 5 10 1
FI2 7 9 VFI2 -1
VFI2 4 0 0
EV16 10 0 9 7 1
CAP 11 10 5.26602e-10
FI1 7 9 VFI1 -1
VFI1 11 6 0
RCAP 6 10 1
D4 0 6 MD3
* Default values used in MD3:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   RS=0 BV=infinite IBV=1mA
.MODEL MD3 D IS=1e-10 N=0.4
.ENDS irf7807zpbf

*SPICE Thermal Model Subcircuit
.SUBCKT irf7807zpbft 3 0

R_RTHERM1         3 2  5.764331
R_RTHERM2         2 1  24.37753
R_RTHERM3         1 0  19.86103
C_CTHERM1         3 2  0.000467
C_CTHERM2         2 1  0.022392
C_CTHERM3         1 0  0.365036

.ENDS irf7807zpbft
